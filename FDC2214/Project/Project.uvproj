# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\bsp\inc
  group Source Group 1
    ./: STARTUP.A51
  group USER
    ./: main.c
  group BSP
    ../bsp/scr/: bsp_delay.c bsp_iic.c
